
require include/techleef-image.inc
