
LICENSE = "CLOSED"

inherit packagegroup

RDEPENDS:${PN} = "a b c d e"
