LICENSE = "CLOSED"

SRC_URI = "\
    file://techleef.c \
    file://Makefile \
"

S = "${WORKDIR}"

inherit module
