LICENSE = "CLOSED"

SRC_URI = "file://techleef.dts"

inherit devicetree
