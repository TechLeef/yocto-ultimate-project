FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

#SRC_URI:append = " file://optimize.cfg"
